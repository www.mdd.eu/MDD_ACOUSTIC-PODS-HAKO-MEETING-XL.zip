Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_MDD_Acustic-pods-Hako-HK03.ifc
Time: 2020-05-27T13:22:26
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Acustic pods Hako - HK03
ePset_BIMobjectScript - Light symbol: On; Floor: On; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Acustic pods Hako - HK03; SKU (BO_prodsku): Hako_HK03; ManufacturName (BO_Manufac): MDD; BrandUrl (BO_brandurl): http://www.mdd.eu; ProductFamily (BO_prodfam): Acustic pods; ProductGroup (BO_prodgroup): Acustic pods; ManufacturCountry (BO_mancont): Poland; DesignCountry (BO_designcont): Poland; EditionNumber (BO_edinum): 1; Width (BO_width): 2762; Height (BO_height): 2341; Depth (BO_depth): 2725; Weight (BO_weight): 935.3; QR (BO_boqrurl): http://bimobject.com/mdd/product/Hako_HK03; ProductDataUrl (BO_prodaturl): bimobject.com/mdd/product/Hako_HK03; ProductUrl (BO_producturl): https://mdd.eu/en/acoustic-pods/hako-meeting-xl/; TechnicalDescription (BO_techcert): https://mdd.eu/media/download/hako_en.pdf; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Metal; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): JN; Uniclass14Description (BO_uniclass_1_4_desc): Furniture/Equipment; Uniclass20Code (BO_uniclass_2_0_code): PR-24; Uniclass20Description (BO_uniclass_2_0_desc): Ducts And Fittings; Uniclass2015Code (BO_uniclass2015_code): Pr_30_36_59_31; Uniclass2015Description (BO_uniclass2015_desc): Furniture stays; NBSReference (BO_nbs_ref): 31; NBSReferenceDescription (BO_nbs_desc): Fittings, Furnishings And Equipment (Ff&E) Products; OmniClassCode (BO_omniclass_code): 23-19 15 21; OmniClassDescription (BO_omniclass_name): Telephone Booths; MasterFormat2014Code (BO_masterformat2014_code): 12 51 00; MasterFormat2014Description (BO_masterformat2014_name): Office Furniture; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
